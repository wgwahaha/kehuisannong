# Keil uVision project EDP.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: EDP +hex
  c flags: Optim=1
  c define: STM32F1OX_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\SYSTEM;..\UDP;..\USER;..\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FELIB
    ../FWLIB/src/: misc.c stm32f10x_crc.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c
  group HARDWARE
    ../HARDWARE/: key.c led.c usart2.c esp8266.c usart3.c timer.c 24l01.c spi.c time2.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart.c
  group UDP
    ../UDP/: cJSON.c EdpKit.c
