# Keil uVision project zijiedian2.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: zijiedian2 +hex
  c flags: Optim=1
  c define: STM32F1OX_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\SYSTEM;..\HARDWARE;..\FWLIB;..\CORE
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../FWLIB/: misc.c stm32f10x_crc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c
  group HARDWARE
    ../HARDWARE/: 24l01.c led.c spi.c usart2.c light_sensor.c light_sensor_io.c adc.c ds18b20.c dht11.c
